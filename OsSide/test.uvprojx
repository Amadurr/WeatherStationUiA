# Keil uVision project test.uvprojx, settings and files
target nRF_Drivers (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WeatherStationUiA
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF52832 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET BSP_DEFINES_ONLY NRF52
  c include: .\config;..\nRF5_SDK_12.2.0\components;..\nRF5_SDK_12.2.0\components\drivers_nrf\common;..\nRF5_SDK_12.2.0\components\drivers_nrf\delay;..\nRF5_SDK_12.2.0\components\drivers_nrf\hal;..\nRF5_SDK_12.2.0\components\drivers_nrf\nrf_soc_nosd;..\nRF5_SDK_12.2.0\components\drivers_nrf\ppi;..\nRF5_SDK_12.2.0\components\drivers_nrf\saadc;..\nRF5_SDK_12.2.0\components\drivers_nrf\timer;..\nRF5_SDK_12.2.0\components\drivers_nrf\uart;..\nRF5_SDK_12.2.0\components\drivers_nrf\gpiote;..\nRF5_SDK_12.2.0\components\drivers_nrf\spi_master;..\nRF5_SDK_12.2.0\components\drivers_nrf\twi_master;..\nRF5_SDK_12.2.0\components\libraries\log;..\nRF5_SDK_12.2.0\components\libraries\log\src;..\nRF5_SDK_12.2.0\components\libraries\util;..\nRF5_SDK_12.2.0\components\toolchain;..\nRF5_SDK_12.2.0\external\segger_rtt;..\nRF5_SDK_12.2.0;.\Drivers;.\Drivers\uart;.\Drivers\pcal;.\Drivers\bsp;.\Resources
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ./: main.c comHub.c util.c util.h twi.c brain.c
    ./config/: sdk_config.h
    ./Resources/: data_Transfer.c
  group nRF_Drivers
    ../../nRF5_SDK_12.2.0/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../nRF5_SDK_12.2.0/components/drivers_nrf/common/: nrf_drv_common.c
    ../../nRF5_SDK_12.2.0/components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../../nRF5_SDK_12.2.0/components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../nRF5_SDK_12.2.0/components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Log
    ../../nRF5_SDK_12.2.0/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Libs
    ../../nRF5_SDK_12.2.0/components/libraries/util/: app_util_platform.c app_error.c app_error_weak.c nrf_assert.c sdk_errors.c
  group Board Definition
    ../../nRF5_SDK_12.2.0/components/boards/: boards.c
target Weatherstation (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: as above
  output: WeatherStationUiA +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c include: .\config;..\..\nRF5_SDK_12.2.0\components;..\..\nRF5_SDK_12.2.0\components\drivers_nrf\common;..\..\nRF5_SDK_12.2.0\components\drivers_nrf\delay;..\..\nRF5_SDK_12.2.0\components\drivers_nrf\hal;..\..\nRF5_SDK_12.2.0\components\drivers_nrf\nrf_soc_nosd;..\..\nRF5_SDK_12.2.0\components\drivers_nrf\ppi;..\..\nRF5_SDK_12.2.0\components\drivers_nrf\saadc;..\..\nRF5_SDK_12.2.0\components\drivers_nrf\timer;..\..\nRF5_SDK_12.2.0\components\drivers_nrf\uart;..\..\nRF5_SDK_12.2.0\components\drivers_nrf\gpiote;..\..\nRF5_SDK_12.2.0\components\drivers_nrf\spi_master;..\..\nRF5_SDK_12.2.0\components\drivers_nrf\twi_master;..\..\nRF5_SDK_12.2.0\components\libraries\log;..\..\nRF5_SDK_12.2.0\components\libraries\log\src;..\..\nRF5_SDK_12.2.0\components\libraries\util;..\..\nRF5_SDK_12.2.0\components\toolchain;..\..\nRF5_SDK_12.2.0\external\segger_rtt;..\..\nRF5_SDK_12.2.0;.\Drivers;.\Drivers\uart;.\Drivers\bsp;.\Resources;-\
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20002128 size 0xded8
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Device:Startup 8.7.1
